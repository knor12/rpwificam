FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://camera.cfg"