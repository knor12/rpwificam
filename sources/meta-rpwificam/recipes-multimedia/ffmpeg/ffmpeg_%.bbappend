PACKAGECONFIG:append = " \
    v4l2 \
    avcodec \
    avformat \
    avdevice \
"