FILES:${PN} += " \
    ${libdir}/rpicam_app.so.* \
"